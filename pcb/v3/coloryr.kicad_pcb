# Repository Coloryr/ColorAudio (continued)

## KiCad design pcb/v2/coloryr.kicad_pcb (continued)

Parts:
C40, C41, C42, C43, C45, C46, C85, C86: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C44: 4.7uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C47: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C48, C49: 10pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
P3: IPEX-SMD_BWIPX-1-001E
R54, R55, R56: 3.3K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R57: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R58, R85, R86, R87, R89, R90: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R81, R82, R84: 4.7K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R88: 10K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
U11, U12: TXS0102DCU; VSSOP-8_2.3x2mm_P0.5mm
U13: AIC8800; AIC8800模组
U17: CH422E; MSOP-10_3x3mm_P0.5mm
Y2: 24.576M; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
1.8V: C40.1, C41.1, C86.1, R54.2, R55.2, R56.2, R81.1, R82.1, R84.1, U11.3 (VCCA), U11.6 (OE), U12.3 (VCCA), U12.6 (OE), Y2.1 (Tri-State), Y2.4 (VDD); also elsewhere on the board
3.3V: C42.1, C43.1, C44.2, C45.2, C46.2, C47.2, C85.1, R57.1, R88.2, U11.7 (VCCB), U12.7 (VCCB), U13.9 (VCC3V3), U13.22 (VDDIO), U17.10 (VCC); also elsewhere on the board
BAT_DM: U17.8 (S1C); also elsewhere on the board
BAT_DP: U17.2 (S1B); also elsewhere on the board
BAT_STAT: R88.1, U17.1 (IN); also elsewhere on the board
DAC_INT: U12.8 (B1); also elsewhere on the board
DAC_INT_1: R55.1, U12.5 (A1); also elsewhere on the board
DAC_LRCK: R82.2; also elsewhere on the board
DAC_MCLK: R85.2; also elsewhere on the board
DAC_PWM: R89.2; also elsewhere on the board
DAC_SCL: U11.1 (B2); also elsewhere on the board
DAC_SCLK: R81.2; also elsewhere on the board
DAC_SCL_1: R56.1, U11.4 (A2); also elsewhere on the board
DAC_SDA: U11.8 (B1); also elsewhere on the board
DAC_SDA_1: R54.1, U11.5 (A1); also elsewhere on the board
DAC_SDIN: R84.2; also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C44.1, C45.1, C46.1, C47.1, C48.2, C49.2, C85.2, C86.2, P3.2 (GND), P3.3 (GND), U11.2 (GND), U12.2 (GND), U13.1 (GND), U13.3 (GND), U13.20 (GND), U13.31 (GND), U13.33 (GND), U13.36 (GND), U17.5 (GND), U17.9 (EN), Y2.2 (GND); also elsewhere on the board
unnamed: C49.1, P3.1 (ANT), R58.1
unnamed: C48.1, R58.2, U13.2 (WL-BT-ANT)
unnamed: R90.2, Y2.3 (OUT)
USB0_DM: R86.2, U17.7 (S2C); also elsewhere on the board
USB0_DP: R87.1, U17.3 (S2B); also elsewhere on the board
USBB_DM: U13.10 (USB_DM); also elsewhere on the board
USBB_DP: U13.11 (USB_DP); also elsewhere on the board
USB_DM: R86.1, U17.6 (DC); also elsewhere on the board
USB_DP: R87.2, U17.4 (DB); also elsewhere on the board

Notes on the sheet:
LEVEL_TRANSLATOR
USB_BAT_SWITCH
USB_WIFI

Parts:
C1, C2, C3: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1: D; D_SOD-323_HandSoldering
J1, J3: Conn_01x02; PinHeader_1x02_P2.00mm_Vertical
J2: Conn_01x03; PinHeader_1x03_P2.00mm_Vertical
R1: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R4, R6: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5: 4.7K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: SOM3562_18; rk3506

Connections:
5V: C2.1, C3.1, C4.1, U1.33 (VCCSYS_IN1), U1.34 (VCCSYS_IN2); also elsewhere on the board
BAT_INT: U1.20 (RM_IO18/SPI0_MISO/REF_CLK1_OUT/GPIO0_C2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); also elsewhere on the board
BAT_SCL: U1.19 (RM_IO19/SPI0_CSN0/ETH_CLK1_25M_OUT/GPIO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); also elsewhere on the board
BAT_SDA: U1.18 (RM_IO20/AUPLL_CLK_IN/ETH_CLK0_25M_OUT/G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); also elsewhere on the board
BOOT: R6.1, U1.86 (SARADC_IN0_BOOT/GPIO4_B0_z)
DAC_INT: U1.27 (RM_IO12/SAI1_SDO0/GPIO0_B4_d); also elsewhere on the board
DAC_LRCK: U1.69 (SAI3_LRCK/DSM_AUD_RP_M1/ETH_RMII0_TXEN/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); also elsewhere on the board
DAC_MCLK: U1.64 (SAI3_MCLK_/ETH_RMII0_RXDVCRS/GPIO2_C0_d); also elsewhere on the board
DAC_PWM: U1.31 (RM_IO8/SPI1_CLK/SAI1_MCLK/GPIO0_B0_d); also elsewhere on the board
DAC_RESET: U1.53 (ETH_RMII1_RXD1/SAI2_SCLK_M0/GPIO3_A7_d); also elsewhere on the board
DAC_SCL: U1.21 (RM_IO17/SPI0_MOSI/GPIO0_C1_d); also elsewhere on the board
DAC_SCLK: U1.70 (SAI3_SCLK/DSM_AUD_RN_M1/ETH_RMII0_TXD1/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); also elsewhere on the board
DAC_SDA: U1.22 (RM_IO16/SPI0_CLK/GPIO0_C0_d); also elsewhere on the board
DAC_SDIN: U1.63 (SAI3_SDO/DSM_AUD_LP_M1/ETH_RMII0_MDIO/G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); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, J1.1, J2.1, J3.1, U1.5 (GND5), U1.10 (GND10), U1.12 (GND12), U1.15 (GND15), U1.17 (GND17), U1.23 (GND23), U1.32 (GND32), U1.35 (GND35), U1.44 (GND44), U1.48 (GND48), U1.61 (GND61), U1.67 (GND67), U1.75 (GND75), U1.82 (GND82), U1.87 (GND87), U1.90 (GND90), U1.97 (GND97), U1.100 (GND100), U1.105 (GND105), U1.110 (GND110), U1.115 (GND115), U1.124 (GND124); also elsewhere on the board
KEY_DOWN: U1.47 (ETH_RMII1_MDC/UART5_TX_M0/GPIO3_B4_d); also elsewhere on the board
KEY_LEFT: U1.50 (ETH_RMII1_TXEN/UART5_RX_M0/GPIO3_B3_d); also elsewhere on the board
KEY_POWER: U1.46 (ETH_RMII1_MDIO/UART5_RTSN_M0/_GPIO3_B5_d); also elsewhere on the board
KEY_RIGHT: U1.49 (ETH_RMII1_CLK/SAI2_SDO_M0/GPIO3_B0_d); also elsewhere on the board
LCD_CLK: U1.109 (FLEXBUS1_D3/DSMC_D0/VO_LCDC_CLK_/GPIO1_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); also elsewhere on the board
LCD_D0: U1.9 (DSMC_SLV_RDYN/RM_IO31/UART5_RX_M1/FLEXB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); also elsewhere on the board
LCD_D1: U1.8 (DSMC_SLV_CSN0/RM_IO30/UART5_TX_M1/FLEXB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); also elsewhere on the board
LCD_D2: U1.7 (DSMC_SLV_D7/RM_IO29/UART5_RTSN_M1/DSM_A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); also elsewhere on the board
LCD_D3: U1.6 (DSMC_SLV_D6/DSM_AUD_LN_M0/FLEXBUS0_D3/D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); also elsewhere on the board
LCD_D4: U1.4 (DSMC_SLV_D5/FLEXBUS0_D4/DSMC_D14/VO_LCD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); also elsewhere on the board
LCD_D5: U1.3 (DSMC_SLV_D4/FLEXBUS0_D5/DSMC_D13/VO_LCD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); also elsewhere on the board
LCD_D6: U1.2 (DSMC_SLV_D3/FLEXBUS0_D6/DSMC_D12/VO_LCD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); also elsewhere on the board
LCD_D7: U1.1 (DSMC_SLV_D2/FLEXBUS0_D7/DSMC_D11/VO_LCD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); also elsewhere on the board
LCD_D8: U1.128 (DSMC_SLV_D1/RM_IO28/SAI2_SDO_M1/FLEXBUS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); also elsewhere on the board
LCD_D9: U1.127 (DSMC_SLV_D0/RM_IO27/SAI2_SDI_M1/FLEXBUS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); also elsewhere on the board
LCD_D10: U1.126 (DSMC_SLV_DQS0/SAI2_MCLK_M1/FLEXBUS1_CSN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); also elsewhere on the board
LCD_D11: U1.125 (DSMC_SLV_CLK/FLEXBUS0_CSN_M4/DSMC_INT1/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); also elsewhere on the board
LCD_D12: U1.123 (FLEXBUS1_CSN_M3/FLEXBUS0_D10/FLEXBUS1_D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); also elsewhere on the board
LCD_D13: U1.122 (FLEXBUS0_CSN_M3/FLEXBUS0_D11/FLEXBUS1_D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); also elsewhere on the board
LCD_D14: U1.121 (FLEXBUS1_CSN_M2/FLEXBUS0_D12/FLEXBUS1_D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); also elsewhere on the board
LCD_D15: U1.120 (FLEXBUS0_CSN_M2/FLEXBUS0_D13/FLEXBUS1_D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); also elsewhere on the board
LCD_D16: U1.119 (RM_IO26/SAI2_LRCK_M1/FLEXBUS1_CSN_M1/FL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); also elsewhere on the board
LCD_D17: U1.118 (RM_IO25/SAI2_SCLK_M1/FLEXBUS0_CSN_M1/FL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); also elsewhere on the board
LCD_D18: U1.117 (RM_IO24/UART5_CTSN_M1/FLEXBUS1_CSN_M0/F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); also elsewhere on the board
LCD_D19: U1.116 (FLEXBUS0_CSN_M0/FLEXBUS1_D8/DSMC_D5/VO_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); also elsewhere on the board
LCD_D20: U1.114 (FLEXBUS1_D7/DSMC_D4/VO_LCDC_D20/GPIO1_A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); also elsewhere on the board
LCD_D21: U1.113 (FLEXBUS1_D6/DSMC_D3/VO_LCDC_D21/GPIO1_A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); also elsewhere on the board
LCD_D22: U1.112 (FLEXBUS1_D5/DSMC_D2/VO_LCDC_D22/GPIO1_A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); also elsewhere on the board
LCD_D23: U1.111 (FLEXBUS1_D4/DSMC_D1/VO_LCDC_D23/GPIO1_A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); also elsewhere on the board
LCD_DE: U1.106 (FLEXBUS1_D0/DSMC_CLKP/VO_LCDC_DEN/GPIO1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); also elsewhere on the board
LCD_EN: U1.62 (SAI3_SDI/DSM_AUD_LN_M1/ETH_RMII0_MDC/GP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); also elsewhere on the board
LCD_HSYNC: U1.108 (FLEXBUS1_D2/DSMC_DQS0/VO_LCDC_HSYNC/GPI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); also elsewhere on the board
LCD_LED: U1.26 (RM_IO13/SAI1_SDO1/GPIO0_B5_d); also elsewhere on the board
LCD_VSYNC: U1.107 (DSMC_SLV_INT/DSMC_INT0/FLEXBUS1_D1/DSMC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); also elsewhere on the board
LED_STATE: U1.28 (RM_IO11/SAI1_SDI/GPIO0_B3_d); also elsewhere on the board
unnamed: D1.1 (K), J2.3
unnamed: J1.2, R3.2
unnamed: J2.2, R4.2
unnamed: J3.2, R6.2
unnamed: R2.2, U1.92 (USB20_OTG0_ID)
unnamed: C1.1, R1.1, U1.68 (VCCIO4_IN)
POWER_ON: U1.45 (ETH_RMII1_RXDVCRS/SAI2_MCLK_M0/GPIO3_B6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); also elsewhere on the board
RECOVER: U1.85 (SARADC_IN1_RECOVERY/GPIO4_B1_z); also elsewhere on the board
RESET: R3.1, U1.16 (NPOR_L)
SD_CLK: U1.60 (NC/SDMMC_CLK/GPIO3_A0_d); also elsewhere on the board
SD_CMD: U1.59 (NC/SDMMC_CMD/GPIO3_A1_d); also elsewhere on the board
SD_D0: U1.57 (NC/SDMMC_D0/GPIO3_A2_d); also elsewhere on the board
SD_D1: U1.56 (NC/TEST_CLK_OUT/SDMMC_D1/GPIO3_A3_d); also elsewhere on the board
SD_D2: U1.55 (NC/JTAG_TCK_M0/SDMMC_D2/GPIO3_A4_d); also elsewhere on the board
SD_D3: U1.58 (NC/JTAG_TMS_M0/SDMMC_D3/GPIO3_A5_d); also elsewhere on the board
SD_DET: U1.54 (ETH_RMII1_RXD0/SAI2_SDI_M0/GPIO3_A6_d); also elsewhere on the board
TP_INT: U1.52 (ETH_RMII1_TXD0/SAI2_LRCK_M0/GPIO3_B1_d); also elsewhere on the board
TP_RESET: U1.51 (ETH_RMII1_TXD1/UART5_CTSN_M0/GPIO3_B2_d); also elsewhere on the board
TP_SCL: U1.24 (RM_IO15/SPI0_CSN1/SAI1_SDO3/GPIO0_B7_d); also elsewhere on the board
TP_SDA: U1.25 (RM_IO14/SPI1_CSN0/SAI1_SDO2/GPIO0_B6_d); also elsewhere on the board
UART0_RX: D1.2 (A), R5.2, U1.13 (RM_IO23/JTAG_TMS_M1/UART0_RX_Debug/GPIO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)
UART0_TX: R4.1, U1.14 (RM_IO22/JTAG_TCK_M1/UART0_TX_Debug/GPIO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)
USB0_DM: U1.93 (USB20_OTG0_DM); also elsewhere on the board
USB0_DP: U1.94 (USB20_OTG0_DP); also elsewhere on the board
USB1_DM: U1.95 (USB20_OTG1_DM); also elsewhere on the board
USB1_DP: U1.96 (USB20_OTG1_DP); also elsewhere on the board
USB_DET: U1.91 (USB20_OTG0_VBUSDET); also elsewhere on the board
VCC_1V8_OUT: R2.1, U1.65 (VCC_1V8_OUT)
VCC_3V3_OUT: R1.2, R5.1, U1.66 (VCC_3V3_OUT)

Parts:
C28: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C29, C37, C38, C39: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C30, C33, C34, C35, C36: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C31: 120pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C32: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D8, D9, D10, D11, D12, D13, D14, D15: ESD9B5.0ST5G; D_SOD-523
D16: D; D_SOD-323_HandSoldering
J12: Conn_01x04; PinHeader_1x04_P2.00mm_Vertical
J13: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical
L4: 10uH; L_TDK_NLV25_2.5x2.0mm
P1: Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
P2: Hirose_FH12-6S-0.5SH_1x06-1MP_P0.50mm_Horizontal
R28, R29, R30, R31, R32, R33: 4.7K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R83: 4.7K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R44: 100K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R45: 10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R46: 1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R47: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R48: 12K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R49: 5.1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R50: 3K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R51: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R52: 100K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R53: 150K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TF1: Micro_SD_Card_Det1; TF-SMD_TF-PUSH
U8: TCKE812
U9: CH334R; QSOP-16_3.9x4.9mm_P0.635mm
U10: STI9287; SOT-23-6_Handsoldering
USB2: USB_A; USB-A-TH_AF-ZJWG
Y1: 12M; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
3.3V: C28.1, C29.1, C33.2, C34.2, C37.2, C38.2, P1.37 (VDD), P2.5 (SDA), R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R83.1, TF1.4 (VDD), U9.12 (V5), U9.13 (VDD33); also elsewhere on the board
5V: C30.1, C36.2, L4.1, U8.2 (EN/UVLO), U8.3 (VIN), U8.4 (VIN), U8.5 (VIN), U10.6 (IN); also elsewhere on the board
BAT_INT: R43.2; also elsewhere on the board
BAT_SCL: R42.2; also elsewhere on the board
BAT_SDA: R41.2; also elsewhere on the board
DAC_SCL: R40.2; also elsewhere on the board
DAC_SDA: R39.2; also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.2, C36.1, C37.1, C38.1, C39.2, D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), D12.1 (A1), D13.1 (A1), D14.1 (A1), D15.1 (A1), J12.1, J13.1, P1.5 (GND), P1.12 (GND), P1.38 (GND), P2.4 (INT), R44.1, R45.1, R47.2, R53.2, TF1.6 (VSS), TF1.10 (SHIELD), TF1.11 (SHIELD), TF1.12 (SHIELD), TF1.13 (SHIELD), U8.11 (GND), U9.14 (GND), U10.2 (GND), USB2.4 (GND), USB2.5 (Shield), Y1.2 (GND), Y1.4 (VDD); also elsewhere on the board
KEY_DOWN: J12.2, R38.2; also elsewhere on the board
KEY_LEFT: J12.4, R36.2; also elsewhere on the board
KEY_RIGHT: J12.3, R37.2; also elsewhere on the board
LCD_CLK: P1.11 (DCLK); also elsewhere on the board
LCD_D0: P1.20 (B0); also elsewhere on the board
LCD_D1: P1.19 (B1); also elsewhere on the board
LCD_D2: P1.18 (B2); also elsewhere on the board
LCD_D3: P1.17 (B3); also elsewhere on the board
LCD_D4: P1.16 (B4); also elsewhere on the board
LCD_D5: P1.15 (B5); also elsewhere on the board
LCD_D6: P1.14 (B6); also elsewhere on the board
LCD_D7: P1.13 (B7); also elsewhere on the board
LCD_D8: P1.28 (G0); also elsewhere on the board
LCD_D9: P1.27 (G1); also elsewhere on the board
LCD_D10: P1.26 (G2); also elsewhere on the board
LCD_D11: P1.25 (G3); also elsewhere on the board
LCD_D12: P1.24 (G4); also elsewhere on the board
LCD_D13: P1.23 (G5); also elsewhere on the board
LCD_D14: P1.22 (G6); also elsewhere on the board
LCD_D15: P1.21 (G7); also elsewhere on the board
LCD_D16: P1.36 (R0); also elsewhere on the board
LCD_D17: P1.35 (R1); also elsewhere on the board
LCD_D18: P1.34 (R2); also elsewhere on the board
LCD_D19: P1.33 (R3); also elsewhere on the board
LCD_D20: P1.32 (R4); also elsewhere on the board
LCD_D21: P1.31 (R5); also elsewhere on the board
LCD_D22: P1.30 (R6); also elsewhere on the board
LCD_D23: P1.29 (R7); also elsewhere on the board
LCD_DE: P1.7 (DE); also elsewhere on the board
LCD_EN: P1.10 (DISP), R83.2; also elsewhere on the board
LCD_HSYNC: P1.9 (HSYNC); also elsewhere on the board
LCD_LED: R46.1; also elsewhere on the board
LCD_VSYNC: P1.8 (VSYNC); also elsewhere on the board
LCD_X1: P1.4 (X1)
LCD_X2: P1.2 (X2)
LCD_Y1: P1.3 (Y1)
LCD_Y2: P1.1 (Y2)
unnamed: D16.2 (A), L4.2, U10.1 (SW)
unnamed: C35.1, D16.1 (K), P1.39 (LED+), U10.5 (OVP)
unnamed: J13.2, R48.2
unnamed: J13.3, R48.1, R49.2
unnamed: J13.4, R49.1, R50.2
unnamed: J13.5, R50.1, R51.2
unnamed: P1.40 (LED-), R45.2, U10.3 (FB)
unnamed: R44.2, U8.10 (ILIM)
unnamed: C31.1, U8.1 (dV/dT)
unnamed: U9.16 (XI), Y1.1 (Tri-State)
unnamed: U9.15 (XO), Y1.3 (OUT)
unnamed: R46.2, R47.1, U10.4 (EN)
unnamed: C32.2, U8.6 (VOUT), U8.7 (VOUT), U8.8 (VOUT), USB2.1 (VBUS)
RECOVER: R51.1; also elsewhere on the board
SD_CLK: D10.2 (A2), TF1.5 (CLK); also elsewhere on the board
SD_CMD: D11.2 (A2), R31.2, TF1.3 (CMD); also elsewhere on the board
SD_D0: D9.2 (A2), R30.2, TF1.7 (DAT0); also elsewhere on the board
SD_D1: D8.2 (A2), R29.2, TF1.8 (DAT1); also elsewhere on the board
SD_D2: D13.2 (A2), R33.2, TF1.1 (DAT2); also elsewhere on the board
SD_D3: D12.2 (A2), R32.2, TF1.2 (DAT3/CD); also elsewhere on the board
SD_DET: R28.2, TF1.CD (DET); also elsewhere on the board
TP_INT: P2.3 (GND); also elsewhere on the board
TP_RESET: P2.6 (SCL); also elsewhere on the board
TP_SCL: P2.1 (RST), R35.2; also elsewhere on the board
TP_SDA: P2.2 (VCC), R34.2; also elsewhere on the board
USB1_DM: U9.10 (DMU-); also elsewhere on the board
USB1_DP: U9.11 (DPU+); also elsewhere on the board
USBA_DM: D14.2 (A2), U9.7 (DM1-), USB2.2 (D-)
USBA_DP: D15.2 (A2), U9.8 (DP1+), USB2.3 (D+)
USBB_DM: U9.5 (DM2-); also elsewhere on the board
USBB_DP: U9.6 (DP2+); also elsewhere on the board
USB_DET: C39.1, R52.2, R53.1; also elsewhere on the board
VCC: R52.1; also elsewhere on the board

Notes on the sheet:
ADC_KEY
VCC_RES
USB_HOST
编码轮
USB_DET
USB_HUB
LCD
TF_Card

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
Board: 2 copper layers, 118.0 x 67.0 mm, 240 parts (0 on the bottom side), 188 nets.

Other parts of the board:
J14: TestPoint; TestPoint_Pad_D2.0mm

Their connections:
DAC_3V3: J14.1; also elsewhere on the board
