# Repository Coloryr/ColorAudio (continued)

## KiCad design pcb/v3/coloryr.kicad_pcb (continued)

Parts:
C28, C43: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C29, C32, C33, C34, C35, C37, C44, C80: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C30, C31: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D8, D9, D10, D11, D12, D13: ESD9B5.0ST5G; D_SOD-523
D16: D; D_SOD-323_HandSoldering
J12: Conn_01x04; PinHeader_1x04_P1.27mm_Vertical
J13: Conn_01x05; PinHeader_1x05_P1.27mm_Vertical
L4: 10uH; L_TDK_NLV25_2.5x2.0mm
P1: LCD_MIPI; Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal
P2: LCD_TOUCH; Hirose_FH12-6S-0.5SH_1x06-1MP_P0.50mm_Horizontal
Q3: NMOS; SOT-23
R12, R81, R85, R90, R91: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R28, R29, R30, R31, R32, R33: 4.7K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R80, R88, R99, R100: 4.7K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R44, R93: 330K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R45: 10; R_0805_2012Metric
R46: 1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R47: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R48: 12K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R49: 5.1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R50: 3K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R51: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R52: 100K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R53: 150K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R54, R56: 3.3K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
TF1: Micro_SD_Card_Det1; TF-SMD_TF-PUSH
U10: STI9287; SOT-23-6_Handsoldering
U11: TXS0102DCU; VSSOP-8_2.3x2mm_P0.5mm
U13: TS3A227E; Texas_RVA_VQFN-16-1EP_3.5x3.5mm_P0.5mm_EP2.14x2.14mm
Y1: 24.576M; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
1.8V: C35.1, C80.1, R54.2, R56.2, U11.3 (VCCA), U11.6 (OE), Y1.1 (Tri-State), Y1.4 (VDD); also elsewhere on the board
3.3V: C28.1, C29.1, C32.2, C33.2, C37.1, C43.1, C44.1, P1.11 (VDD), P1.12 (VDD), P2.1 (VDD), R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.2, R80.1, R81.2, R88.1, R93.2, R99.1, R100.1, TF1.4 (VDD), U11.7 (VCCB), U13.4 (VDD); also elsewhere on the board
5V: C31.2, L4.1, U10.6 (IN); also elsewhere on the board
BAT_INT: R43.2; also elsewhere on the board
BAT_SCL: R42.2; also elsewhere on the board
BAT_SDA: R41.2; also elsewhere on the board
DAC_INT_A: R99.2; also elsewhere on the board
DAC_INT_B: R100.2; also elsewhere on the board
DAC_MCLK: R85.2; also elsewhere on the board
DAC_MCLK_1: R85.1, R90.1; also elsewhere on the board
DAC_SCL: R40.2, U11.1 (B2), U13.9 (SCL); also elsewhere on the board
DAC_SCL_1: R56.1, U11.4 (A2); also elsewhere on the board
DAC_SDA: R39.2, U11.8 (B1), U13.3 (SDA); also elsewhere on the board
DAC_SDA_1: R54.1, U11.5 (A1); also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C34.2, C35.2, C37.2, C43.2, C44.2, C80.2, D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), D12.1 (A1), D13.1 (A1), J12.1, J13.1, P1.1 (GND), P1.4 (GND), P1.7 (GND), P1.10 (GND), P1.13 (GND), P1.15 (GND), P1.17 (GND), P1.19 (GND), P1.23 (GND), P1.MP, P2.6 (GND), P2.MP, Q3.3 (S), R45.1, R47.2, R53.2, TF1.6 (VSS), TF1.10 (SHIELD), TF1.11 (SHIELD), TF1.12 (SHIELD), TF1.13 (SHIELD), U10.2 (GND), U11.2 (GND), U13.1 (GND), U13.2 (GND), U13.11 (GNDA), U13.17 (GND), Y1.2 (GND); also elsewhere on the board
HP_CONTROL: U13.6 (MICP); also elsewhere on the board
HP_DETECT: R80.2; also elsewhere on the board
HP_DETECT1: Q3.1 (D), R44.1, U13.15 (DET_TRIGGER); also elsewhere on the board
HP_DETECT_IO: Q3.2 (G), R93.1; also elsewhere on the board
HP_INT: R88.2, U13.13 (INT); also elsewhere on the board
HP_RING2: U13.7 (RING2_SENSE), U13.12 (RING2); also elsewhere on the board
HP_SLEEVE: U13.8 (SLEEVE_SENSE), U13.10 (SLEEVE); also elsewhere on the board
HP_TIP: U13.14 (TIP); also elsewhere on the board
KEY_DOWN: J12.2, R38.2; also elsewhere on the board
KEY_LEFT: J12.4, R36.2; also elsewhere on the board
KEY_RIGHT: J12.3, R37.2; also elsewhere on the board
LCD_CLKN: P1.5 (CLKN); also elsewhere on the board
LCD_CLKP: P1.6 (CLKP); also elsewhere on the board
LCD_D0N: P1.2 (D0N); also elsewhere on the board
LCD_D0P: P1.3 (D0P); also elsewhere on the board
LCD_D1N: P1.8 (D1N); also elsewhere on the board
LCD_D1P: P1.9 (D1P); also elsewhere on the board
LCD_LED: R46.1; also elsewhere on the board
LCD_RESET: P1.18 (RESET); also elsewhere on the board
LCD_VDDIO: P1.14 (IOVCC), R12.1, R81.1
MIC_GND: U13.5 (GND_SENSE); also elsewhere on the board
unnamed: D16.2 (A), L4.2, U10.1 (SW)
unnamed: C30.1, D16.1 (K), P1.24 (LEDA), U10.5 (OVP)
unnamed: J13.2, R48.2
unnamed: J13.3, R48.1, R49.2
unnamed: J13.4, R49.1, R50.2
unnamed: J13.5, R50.1, R51.2
unnamed: P1.22 (LEDK), R45.2, U10.3 (FB)
unnamed: P2.5 (RESET), R91.1
unnamed: R46.2, R47.1, U10.4 (EN)
unnamed: R90.2, Y1.3 (OUT)
RECOVER: R51.1; also elsewhere on the board
SD_CLK: D10.2 (A2), TF1.5 (CLK); also elsewhere on the board
SD_CMD: D11.2 (A2), R31.2, TF1.3 (CMD); also elsewhere on the board
SD_D0: D9.2 (A2), R30.2, TF1.7 (DAT0); also elsewhere on the board
SD_D1: D8.2 (A2), R29.2, TF1.8 (DAT1); also elsewhere on the board
SD_D2: D13.2 (A2), R33.2, TF1.1 (DAT2); also elsewhere on the board
SD_D3: D12.2 (A2), R32.2, TF1.2 (DAT3/CD); also elsewhere on the board
SD_DET: R28.2, TF1.CD (DET); also elsewhere on the board
TP_INT: P2.2 (EINT); also elsewhere on the board
TP_RESET: R91.2; also elsewhere on the board
TP_SCL: P2.3 (SCL), R35.2; also elsewhere on the board
TP_SDA: P2.4 (SDA), R34.2; also elsewhere on the board
USB_DET: C34.1, R52.2, R53.1; also elsewhere on the board
VCC: R52.1; also elsewhere on the board
VCC_1V8_OUT: R12.2; also elsewhere on the board

Notes on the sheet:
ADC_KEY
编码轮
VCC_RES
USB_DET
LCD
LEVEL_TRANSLATOR
TF_Card

Board: 2 copper layers, 43.4 x 75.3 mm, 234 parts (47 on the bottom side), 171 nets.

File pcb/v3/bom.csv:

Reference,Qty,Value,Footprint,,,,,,µ¥¼Û,×Ü¼Æ
"C1,C2,C3,C7,C8,C23,C25,C26,C27",9,22uF,Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,,,,,0.066,0.594
"C4,C5,C10,C12,C13,C14,C18,C19,C20,C28,C42,C43,C51,C65,C74,C78",16,10uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0385,0.616
"C6,C29,C32,C33,C34,C35,C37,C38,C41,C44,C45,C46,C50,C59,C60,C64,C80,C81",18,0.1uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.297
"C9,C11,C15,C21,C22,C30,C31",7,1uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.022,0.154
C16,1,47nF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.0165
"C17,C39",2,4.7uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.033,0.066
C24,1,10nF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.0165
"C36,C79",2,10uF,Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,,,,,0.044,0.088
C40,1,100nF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.0165
"C47,C48,C49,C54,C55,C56,C57,C58,C61,C62,C63,C68,C69,C70,C71,C72",16,2.2uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0275,0.44
"C52,C53,C66,C67",4,15uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.2,0.8
"C73,C77",2,1.0uF,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.022,0.044
"C75,C76",2,4.7nf,Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,,,,,,0.055,0.11
CN1,1,PJ-625G,coloryr:AUDIO-TH_PJ-625G,,,,,,3.02,3.02
"D1,D4,D5,D16",4,1N5819,Diode_SMD:D_SOD-323_HandSoldering,,,,,,0.033,0.132
"D2,D3,D8,D9,D10,D11,D12,D13",8,ESD9B5.0ST5G,Diode_SMD:D_SOD-523,,,,,,0.044,0.352
"D6,D7",2,LED,Diode_SMD:D_0402_1005Metric_Pad0.77x0.64mm_HandSolder,,,,,,0.044,0.088
"J1,J3,J5,J6,J7,J8,J11,J14,J15",9,TestPoint,TestPoint:TestPoint_Pad_D1.0mm,,,,,,0,0
J2,1,Conn_01x03,Connector_PinHeader_1.27mm:PinHeader_1x03_P1.27mm_Vertical,,,,,,0,0
"J4,J10",2,Conn_01x02,Connector_PinHeader_2.00mm:PinHeader_1x02_P2.00mm_Vertical,,,,,,0,0
J9,1,Conn_01x02,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,,,,,,0,0
J12,1,Conn_01x04,Connector_PinHeader_1.27mm:PinHeader_1x04_P1.27mm_Vertical,,,,,,0,0
J13,1,Conn_01x05,Connector_PinHeader_1.27mm:PinHeader_1x05_P1.27mm_Vertical,,,,,,0,0
"L1,L2",2,"2,2uH",Inductor_SMD:L_1008_2520Metric_Pad1.43x2.20mm_HandSolder,,,,,,0.3,0.6
L3,1,1.0uH,Inductor_SMD:L_Changjiang_FXL0530,,,,,,0.39,0.39
L4,1,10uH,Inductor_SMD:L_TDK_NLV25_2.5x2.0mm,,,,,,0.3,0.3
P1,1,LCD_MIPI,Connector_FFC-FPC:Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal,,,,,,0.3,0.3
P2,1,LCD_TOUCH,Connector_FFC-FPC:Hirose_FH12-6S-0.5SH_1x06-1MP_P0.50mm_Horizontal,,,,,,0.24,0.24
PJ1,1,~,coloryr:AUDIO-IN-SMD_PJ-327A_C22355751,,,,,,0.28,0.28
Q1,1,NPN,coloryr:SOT-23,,,,,,0.11,0.11
Q2,1,PMOS,coloryr:SOT-23,,,,,,1.21,1.21
Q3,1,NMOS,coloryr:SOT-23,,,,,,3.19,3.19
"R1,R12,R59,R60,R63,R64,R81,R85,R90,R91",10,0,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.132
"R2,R18,R19,R20,R22,R47,R75,R95",8,10K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.1056
"R3,R4,R6,R51",4,100,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0528
"R5,R28,R29,R30,R31,R32,R33",7,4.7K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0924
"R7,R8",2,2.2R,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0264
"R9,R25",2,100K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0264
R10,1,750K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
R11,1,240K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
R13,1,220K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
R14,1,510K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
R15,1,260,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
"R16,R17,R26,R27,R55,R57,R87",7,10K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0924
"R21,R46",2,1K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0264
R23,1,12K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
R24,1,390K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
"R34,R35,R36,R37,R38,R39,R40,R41,R42,R43,R80,R88",12,4.7K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.1584
"R44,R93",2,330K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0264
R45,1,10,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.0165
R48,1,12K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0132
R49,1,5.1K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0132
R50,1,3K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0132
R52,1,100K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0132
R53,1,150K,Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder,,,,,,0.0132,0.0132
"R54,R56",2,3.3K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0264
R58,1,30K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0132,0.0132
"R61,R62,R65,R66",4,50,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.066
"R67,R69",2,510,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.033
"R68,R70",2,71.5,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.033
"R71,R72",2,82,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.033
"R73,R74,R76,R77,R78,R79",6,0,Resistor_SMD:R_0805_2012Metric,,,,,,0.0165,0.099
"R82,R83",2,5.1K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.033
R84,1,22.6K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.0165
R86,1,12.7K,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.0165
"R89,R92,R94,R96,R97,R98",6,22,Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder,,,,,,0.0165,0.099
RF1,1,6GHz,coloryr:IPEX-SMD_BWIPX-3-001E-1,,,,,,0.38,0.38
"RV1,RV2",2,R_Potentiometer,Potentiometer_SMD:Potentiometer_Bourns_TC33X_Vertical,,,,,,1.9,3.8
TF1,1,Micro_SD_Card_Det1,coloryr:TF-SMD_TF-PUSH,,,,,,0.24,0.24
U1,1,SOM3562_18,coloryr:rk3506,,,,,,65,65
U2,1,TLV6213x,Package_DFN_QFN:VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias,,,,,,1.81,1.81
U3,1,RT9013,Package_TO_SOT_SMD:SOT-23-5,,,,,,0.48,0.48
U4,1,BQ25895RTW,Package_DFN_QFN:Texas_RTW_WQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_ThermalVias,,,,,,4.7,4.7
U5,1,LM27762,Package_SON:WSON-12-1EP_3x2mm_P0.5mm_EP1x2.65_ThermalVias,,,,,,3.78,3.78
U6,1,LP5907MFX-3.3,Package_TO_SOT_SMD:SOT-23-5,,,,,,0.42,0.42
U7,1,TPS61230DRC,Package_SON:Texas_S-PVSON-N10_ThermalVias,,,,,,3,3
U8,1,M8800DU6,coloryr:BL_M8800DU6_40L,,,,,,15,15
U9,1,SY6280,Package_TO_SOT_SMD:SOT-23-5,,,,,,0.31,0.31
U10,1,STI9287,Package_TO_SOT_SMD:SOT-23-6_Handsoldering,,,,,,0.24,0.24
U11,1,TXS0102DCU,Package_SON:X2SON-8_1.4x1mm_P0.35mm,,,,,,0.69,0.69
U12,1,SN74AVC4T245PW,Package_DFN_QFN:UQFN-16_1.8x2.6mm_P0.4mm,,,,,,0.99,0.99
U13,1,TS3A227E,Package_DFN_QFN:Texas_RVA_VQFN-16-1EP_3.5x3.5mm_P0.5mm_EP2.14x2.14mm,,,,,,5.93,5.93
"U14,U15",2,CS43198,Package_DFN_QFN:QFN-40-1EP_5x5mm_P0.4mm_EP3.6x3.6mm_ThermalVias,,,,,,19,38
U16,1,OPA1622,Package_SON:Texas_S-PVSON-N10,,,,,,5.68,5.68
USB1,1,USB_C_Plug_USB2.0,Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,,,,,,0.17,0.17
Y1,1,24.576M,Oscillator:Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm,,,,,,1.8,1.8
LCD1,1,D310T9362V1,,,,,,,65,65
BAT,1,8000mah,,,,,,,20,20
,,,,,,,,,,
,,,,,,,,,,
,,,,,,,,,,
,,,,,,,,,,
,,,,,,,,,,252.2732

## KiCad design pcb/v2/coloryr.kicad_pcb

Parts:
C5, C10, C12, C13, C14, C18, C19, C20: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C7, C8, C25, C26, C27: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C11, C15, C21, C22: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C16: 47nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C17: 4.7uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C23: 22uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C24: 10nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D2, D3: ESD9B5.0ST5G; D_SOD-523
D4, D5: D; D_SOD-323_HandSoldering
D6, D7: LED; D_0402_1005Metric_Pad0.77x0.64mm_HandSolder
J4, J9: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5, J6, J7, J8, J11: TestPoint; TestPoint_Pad_D2.0mm
J10: Conn_01x02; PinHeader_1x02_P2.00mm_Vertical
L1, L2: 2,2uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
L3: 1.0uH; L_Changjiang_FXL0530
Q1: NPN; SOT-23
Q2: PMOS; SOT-23
R7, R8: 2.2R; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R9, R25: 100K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R10: 750K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R11: 240K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R12, R16, R17, R26, R27: 10K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R13: 549K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R14: 511K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R15: 260; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R18, R19, R22: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R20: 100K/NC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23: 12K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R24: 390K; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
RV1, RV2: R_Potentiometer; Potentiometer_Bourns_3296W_Vertical
U2: TLV6213x; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias
U3: SOT-23-5_HandSoldering
U4: BQ25895RTW; Texas_RTW_WQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_ThermalVias
U5: LM27762; WSON-12-1EP_3x2mm_P0.5mm_EP1x2.65_ThermalVias
U6: LP5907MFX-3.3; SOT-23-5
U7: TPS61230DRC; Texas_S-PVSON-N10_ThermalVias
USB1: USB_C_Plug_USB2.0; USB_C_Receptacle_GCT_USB4085

Connections:
1.8V: C9.1, J6.1, U3.5 (OUT); also elsewhere on the board
3.3V: C7.1, C8.1, J5.1, L1.2, R9.1, R10.1, R18.1, U2.14 (VOS); also elsewhere on the board
5V: C5.1, C6.1, C10.1, C21.1, C25.1, C26.1, C27.1, J11.1, R12.1, R23.1, U2.10 (AVIN), U2.11 (PVIN), U2.12 (PVIN), U2.13 (EN), U3.1 (VIN), U3.3 (CE), U5.3 (VIN), U5.8 (EN-), U5.12 (EN+), U6.1 (IN), U6.3 (EN), U7.3 (VOUT), U7.4 (VOUT); also elsewhere on the board
BAT_DM: U4.3 (D-); also elsewhere on the board
BAT_DP: U4.2 (D+); also elsewhere on the board
BAT_INT: U4.7 (INT); also elsewhere on the board
BAT_SCL: U4.5 (SCL); also elsewhere on the board
BAT_SDA: U4.6 (SDA); also elsewhere on the board
BAT_STAT: U4.4 (STAT); also elsewhere on the board
DAC_3V3: C22.1, U6.5 (OUT); also elsewhere on the board
GND: C5.2, C7.2, C8.2, C9.2, C10.2, C12.1, C13.1, C14.1, C15.2, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.2, D2.1 (A1), D3.1 (A1), D6.1 (K), D7.1 (K), J4.1, J9.2, J10.1, Q1.3 (E), R11.2, R13.1, R15.2, R17.2, R20.1, R22.2, R25.2, RV2.2, U2.6 (AGND), U2.7 (FSW), U2.8 (DEF), U2.15 (PGND), U2.16 (PGND), U2.17 (TAP), U3.2 (GND), U4.9 (~CE), U4.17 (PGND), U4.18 (PGND), U4.25 (PGND), U5.4 (GND), U5.13 (PAD), U6.2 (GND), U7.11 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD); also elsewhere on the board
KEY_POWER: D4.2 (A), R18.2; also elsewhere on the board
LED_STATE: R27.1; also elsewhere on the board
unnamed: C16.2, L2.1, U4.19 (SW), U4.20 (SW)
unnamed: D4.1 (K), D5.1 (K), J10.2
unnamed: D5.2 (A), Q1.1 (C), Q2.2 (G), R19.2
unnamed: D6.2 (A), R26.2
unnamed: D7.2 (A), R27.2
unnamed: C18.1, J9.1, U4.13 (BAT), U4.14 (BAT)
unnamed: L1.1, U2.1 (SW), U2.2 (SW), U2.3 (SW)
unnamed: L3.2, U7.1 (SW), U7.2 (SW)
unnamed: Q1.2 (B), R20.2, R21.2
unnamed: R7.2, USB1.A7 (D-), USB1.B7 (D-)
unnamed: R8.2, USB1.A6 (D+), USB1.B6 (D+)
unnamed: R23.2, R24.1
unnamed: R10.2, R11.1, U2.5 (FB)
unnamed: R9.2, U2.4 (PG)
unnamed: C6.2, U2.9 (SS/TR)
unnamed: C16.1, U4.21 (BTST)
unnamed: R15.1, U4.10 (ILIM)
unnamed: C17.2, R16.1, U4.22 (REGN)
unnamed: R16.2, R17.1, U4.11 (TS)
unnamed: C11.2, U5.10 (C+)
unnamed: C11.1, U5.9 (C-)
unnamed: C12.2, U5.5 (CP)
unnamed: R13.2, RV1.1, U5.2 (FB+)
unnamed: R14.2, RV2.3, U5.7 (FB-)
unnamed: R12.2, U5.1 (PGOOD)
unnamed: R24.2, R25.1, U7.7 (FB)
unnamed: C24.2, U7.6 (SS)
OP+: C13.2, J7.1, RV1.2, U5.11 (OUT+); also elsewhere on the board
OP-: C14.2, J8.1, R14.1, U5.6 (OUT-); also elsewhere on the board
POWER_EN: Q2.1 (D), R22.1, R26.1, U7.9 (EN)
POWER_ON: R21.1; also elsewhere on the board
SYS: C19.1, C20.1, C23.1, L2.2, L3.1, Q2.3 (S), R19.1, U4.15 (SYS), U4.16 (SYS), U7.10 (VIN)
USB_DM: D3.2 (A2), R7.1; also elsewhere on the board
USB_DP: D2.2 (A2), R8.1; also elsewhere on the board
VCC: C15.1, J4.2, U4.1 (VBUS), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS); also elsewhere on the board

Notes on the sheet:
POWER LED
BAT
LDO 3.3V
POWER_SWITCH
LDO 1.8V
DC-DC 3.3V
POWER 4.5V
USB-TypeC
POWER 5V

Parts:
C50, C51, C55, C64, C65, C69: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C52, C53, C54, C59, C60, C61, C62, C63, C66, C67, C68, C73, C74, C75, C76, C77: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C56, C70, C79, C83: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C57, C58, C71, C72: 15uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C78, C82: 1.0uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C80, C81: 4.7nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C84: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CN1: AUDIO-TH_PJ-625G
R59, R60, R63, R64: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R61, R62, R65, R66: 50; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R67, R69: 510; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68, R70: 71.5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R71, R72: 82; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R73, R74, R75, R76, R77, R78, R79: 0; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R80: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U14, U15: CS43198; QFN-40-1EP_5x5mm_P0.4mm_EP3.6x3.6mm_ThermalVias
U16: OPA1622; Texas_S-PVSON-N10

Connections:
1.8V: C57.2, C59.2, C62.2, C71.2, C73.2, C76.2, R59.2, R60.2, R63.2, R64.2, R80.2, U14.7 (VA), U14.25 (VCP), U14.30 (ADR), U15.7 (VA), U15.25 (VCP); also elsewhere on the board
+INA: R62.1, R66.1, R68.2
+INB: R61.1, R65.1, R70.2
-INA: R67.2, R78.2
-INB: R69.2, R79.2
DAC_3V3: C55.2, C56.1, C69.2, C70.1, U14.26 (VP), U15.26 (VP); also elsewhere on the board
DAC_INT_1: U14.27 (INT); also elsewhere on the board
DAC_LRCK: U14.38 (LRCK1), U15.38 (LRCK1); also elsewhere on the board
DAC_RESET: U14.28 (RESET), U15.28 (RESET); also elsewhere on the board
DAC_SCLK: U14.34 (SCLK1), U15.34 (SCLK1); also elsewhere on the board
DAC_SCL_1: U14.1 (SCL), U15.1 (SCL); also elsewhere on the board
DAC_SDA_1: U14.39 (SDA), U15.39 (SDA); also elsewhere on the board
DAC_SDIN: U14.2 (SDIN1), U15.2 (SDIN1); also elsewhere on the board
GND: C50.2, C51.2, C55.1, C56.2, C59.1, C60.1, C61.1, C62.1, C63.1, C64.2, C65.2, C69.1, C70.2, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C82.1, C83.1, C84.2, CN1.1, R73.1, R74.1, R78.1, R79.1, U14.8 (GNDA), U14.12 (GNDCP), U14.15 (GNDCP), U14.19 (GNDCP), U14.35 (GNDD), U14.36 (XTO), U14.41 (THERM), U15.8 (GNDA), U15.12 (GNDCP), U15.15 (GNDCP), U15.19 (GNDCP), U15.30 (ADR), U15.35 (GNDD), U15.36 (XTO), U15.41 (THERM), U16.3 (GND); also elsewhere on the board
HP_DETECT: C84.1, R75.2, R80.1, U14.22 (HP_DETECT)
unnamed: CN1.3, CN1.4 (3), R76.1
unnamed: CN1.2, CN1.5, R77.1
unnamed: CN1.6, R75.1
unnamed: C58.2, C63.2, U14.9 (-VA)
unnamed: R62.2, U14.14 (AOUTA)
unnamed: R61.2, U14.16 (AOUTB)
unnamed: C57.1, U14.5 (FILT+)
unnamed: C58.1, U14.6 (FILT-)
unnamed: C53.1, C54.1, U14.23 (FLYC_VCP)
unnamed: C52.1, U14.11 (FLYN_VA)
unnamed: C54.2, U14.20 (FLYN_VCP)
unnamed: C52.2, U14.10 (FLYP_VA)
unnamed: C53.2, U14.24 (FLYP_VCP)
unnamed: C60.2, U14.21 (VCP_FILT+)
unnamed: C61.2, U14.18 (VCP_FILT-)
unnamed: C51.1, R60.1, U14.4 (VD)
unnamed: C50.1, R59.1, U14.31 (VL)
unnamed: C72.2, C77.2, U15.9 (-VA)
unnamed: R66.2, U15.14 (AOUTA)
unnamed: R65.2, U15.16 (AOUTB)
unnamed: C71.1, U15.5 (FILT+)
unnamed: C72.1, U15.6 (FILT-)
unnamed: C67.1, C68.1, U15.23 (FLYC_VCP)
unnamed: C66.1, U15.11 (FLYN_VA)
unnamed: C68.2, U15.20 (FLYN_VCP)
unnamed: C66.2, U15.10 (FLYP_VA)
unnamed: C67.2, U15.24 (FLYP_VCP)
unnamed: C74.2, U15.21 (VCP_FILT+)
unnamed: C75.2, U15.18 (VCP_FILT-)
unnamed: C65.1, R64.1, U15.4 (VD)
unnamed: C64.1, R63.1, U15.31 (VL)
unnamed: R68.1, U16.1 (+)
unnamed: C80.2, R67.1, R71.2, U16.10 (-)
unnamed: R70.1, U16.5 (+)
unnamed: C81.2, R69.1, R72.2, U16.6 (-)
OP+: C82.2, C83.2, U16.2 (V+), U16.8 (EN); also elsewhere on the board
OP-: C78.2, C79.2, U16.4 (V-), U16.11 (V-); also elsewhere on the board
OUT_A: C80.1, R71.1, R76.2, U16.9
OUT_B: C81.1, R72.1, R77.2, U16.7
REF_A: R74.2, U14.13 (REFA), U15.13 (REFA)
REF_B: R73.2, U14.17 (REFB), U15.17 (REFB)
